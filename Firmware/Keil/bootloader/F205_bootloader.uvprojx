# Keil uVision project F205_bootloader.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F205RCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F205 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c misc: -Wunused-parameter
  c include: .\Core\src;.\Core\inc;.\Llib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ./Core/src/: main.c stm32f205_clock.c string_convertor.c device_model.c stm32f105_clock.c runtime.c
    ./Core/inc/: main.h
    ../template/Core/src/: watchdog.c
  group Llib
    ./Llib/inc/: stm32f205xx.h stm32f105xc.h stm32h730xx.h
  group Board_models
    ./Core/src/Board_models/F105/: DEVICE_1CAN2LIN.c DEVICE_2CAN.c DEVICE_2CAN_BOXED.c DEVICE_2CAN_TJA1042.c DEVICE_SIGMA.c
    ./Core/src/Board_models/F205/: DEVICE_ALLIGATOR.c DEVICE_FCAN_V6.c DEVICE_TEC_MODULE.c
  group SPI
    ./Core/src/SPI/: spi.c spi_1xx.c spi_7xx.c
  group Flash_memchip
    ./Core/src/Flash_memchip/: flash_nand_mem_chip_spi.c flash_nor_mem_chip_spi.c
  group Flash
    ./Core/src/Flash/: flash_f105.c flash_f205.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.2.1
