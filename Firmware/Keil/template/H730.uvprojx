# Keil uVision project H730.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32H730ZBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H730 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Core\inc;.\Llib\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Core
    ./Core/src/: main.c stm32h730_clock.c device_model.c string_convertor.c runtime.c watchdog.c extras.c ram_updater.c vehicle_template.c
  group Llib
    ./Llib/inc/: stm32h730xx.h
  group Commands
    ./Core/src/Commands/: cmd_specific.c cmd_lin.c cmd_set_vehicle_value.c cmd_spi_memchip_read.c common_cmd.c device_modes.c cmd_fdcan.c cmd_raw.c test_cmd_nand.c cmd_memchip_base.c el_protocol.c user_cmd.c
  group Board_models
    ./Core/src/Board_models/F105/: DEVICE_1CAN2LIN.c DEVICE_2CAN.c DEVICE_2CAN_BOXED.c DEVICE_2CAN_TJA1042.c DEVICE_SIGMA.c
    ./Core/src/Board_models/F205/: DEVICE_ALLIGATOR.c DEVICE_FCAN_V6.c DEVICE_TEC_MODULE.c
    ./Core/src/Board_models/H730/: DEVICE_PRZRK8XL.c
  group BxCAN
    ./Core/src/BxCAN/: can.c can_buffer.c can_cdc_player.c can_cdc_player_buffer.c can_override.c can_scanner.c
  group FDCAN
    ./Core/src/FDCAN/: fdcan.c fdcan_buffer.c fdcan_can_override.c fdcan_scanner.c fdcan_std_can_legacy.c
  group Flash_memchip
    ./Core/src/Flash_memchip/: flash_nand_mem_chip_spi.c flash_nor_mem_chip_spi.c
  group USART
    ./Core/src/USART/: usart.c usart_rx_buffer.c
  group USB_CDC
    ./Core/src/USB_CDC/: stm32h7xx_usbdfs_cdc.c stm32f105_usbdfs_cdc.c
  group TIM
    ./Core/src/TIM/: tim.c
  group SPI
    ./Core/src/SPI/: spi.c spi_1xx.c spi_7xx.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.11.0
