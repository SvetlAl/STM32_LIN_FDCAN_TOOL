# Keil uVision project F407.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c include: .\Core\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ./Core/src/: main.c device_model.c extras.c ram_updater.c runtime.c stm32f407_clock.c string_convertor.c vehicle_template.c watchdog.c
  group Llib
    ./Llib/inc/: stm32f105xc.h stm32f205xx.h stm32f407xx.h stm32h730xx.h
  group Commands
    ./Core/src/Commands/: cmd_fdcan.c cmd_lin.c cmd_memchip_base.c cmd_raw.c cmd_set_vehicle_value.c cmd_specific.c cmd_spi_memchip_read.c common_cmd.c device_modes.c el_protocol.c test_cmd_nand.c user_cmd.c
  group Board_models
    ./Core/src/Board_models/F105/: DEVICE_1CAN2LIN.c DEVICE_2CAN.c DEVICE_2CAN_BOXED.c DEVICE_2CAN_TJA1042.c DEVICE_SIGMA.c
    ./Core/src/Board_models/F205/: DEVICE_ALLIGATOR.c DEVICE_FCAN_V6.c DEVICE_TEC_MODULE.c
    ./Core/src/Board_models/F407/: DEVICE_DEVBOARD_F407VET_A.c
    ./Core/src/Board_models/H730/: DEVICE_PRZRK8XL.c
  group BxCAN
    ./Core/src/BxCAN/: can.c can_buffer.c can_cdc_player.c can_cdc_player_buffer.c can_override.c can_scanner.c
  group SPI
    ./Core/src/SPI/: spi.c spi_1xx.c spi_7xx.c
  group Flash_memchip
    ./Core/src/Flash_memchip/: flash_nand_mem_chip_spi.c flash_nor_mem_chip_spi.c
  group USART
    ./Core/src/USART/: usart.c usart_rx_buffer.c
  group USB_CDC
    ./Core/src/USB_CDC/: stm32f105_usbdfs_cdc.c
  group DMA10x
    ./Core/src/DMAF10x/: 10x_dma.c
  group TIM
    ./Core/src/TIM/: tim.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
