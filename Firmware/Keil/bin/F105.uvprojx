# Keil uVision project F105.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F105 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c include: .\Core\src;.\Core\inc;.\Llib\inc
  memory RVCT4: ROM 0x8004000 size 0x3c000
  memory RVCT9: RAM 0x20000c00 size 0x17400
  scatter file: .\Llib\105.sct
  group Core
    ./Core/src/: main.c stm32f105_clock.c string_convertor.c watchdog.c device_model.c stm32f205_clock.c extras.c runtime.c ram_updater.c stm32h730_clock.c vehicle_template.c
    ./Core/inc/: stm32f105_clock.h main.h
  group Llib
    ./Llib/inc/: stm32f105xc.h
  group Commands
    ./Core/src/Commands/: cmd_fdcan.c cmd_lin.c cmd_memchip_base.c cmd_raw.c cmd_set_vehicle_value.c cmd_specific.c cmd_spi_memchip_read.c common_cmd.c device_modes.c el_protocol.c test_cmd_nand.c user_cmd.c
  group Board_models
    ./Core/src/Board_models/F105/: DEVICE_1CAN2LIN.c DEVICE_2CAN.c DEVICE_2CAN_BOXED.c DEVICE_2CAN_TJA1042.c DEVICE_SIGMA.c
  group BxCAN
    ./Core/src/BxCAN/: can.c can_buffer.c can_cdc_player.c can_cdc_player_buffer.c can_override.c can_scanner.c
  group SPI
    ./Core/src/SPI/: spi.c spi_1xx.c spi_7xx.c
  group Flash_memchip
    ./Core/src/Flash_memchip/: flash_nand_mem_chip_spi.c flash_nor_mem_chip_spi.c
  group USART
    ./Core/src/USART/: usart.c usart_rx_buffer.c
  group USB_CDC
    ./Core/src/USB_CDC/: stm32f105_usbdfs_cdc.c stm32h7xx_usbdfs_cdc.c
  group DMA10x
    ./Core/src/DMAF10x/: 10x_dma.c
  group TIM
    ./Core/src/TIM/: tim.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
