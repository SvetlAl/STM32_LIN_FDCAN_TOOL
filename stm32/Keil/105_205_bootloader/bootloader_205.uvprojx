# Keil uVision project bootloader_205.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F205RCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usb_cdc_105_lib +hex
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c misc: -Wunused-parameter
  c include: .\Core\src;.\Core\inc;.\Llib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ./Core/src/: main.c stm32f205_clock.c string_convertor.c spi.c flash_mem_chip_spi.c device_model.c flash.c
    ./Core/inc/: main.h
  group Llib
    ./Llib/inc/: stm32f205xx.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.2.1
