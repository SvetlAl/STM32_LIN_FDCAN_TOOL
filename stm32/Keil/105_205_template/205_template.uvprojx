# Keil uVision project 205_template.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F205RCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usb_cdc_105_lib +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c misc: -Wunused-parameter
  c include: .\Core\src;.\Core\inc;.\Llib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ./Core/src/: main.c watchdog.c stm32f205_clock.c stm32f105_usbdfs_cdc.c string_convertor.c spi.c flash_mem_chip_spi.c user_cmd.c el_protocol.c vehicle.c can.c tim.c device_model.c can_override.c stm32f105_clock.c cdc_flow_can_buffer.c 10x_dma.c can_buffer.c extras.c runtime.c
    ./Core/inc/: main.h stm32f105_usbdfs_cdc.h stm32f105_usbdfs_macros.h usb_cdc_desc.h
  group Llib
    ./Llib/inc/: stm32f205xx.h stm32f105xc.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.2.1
